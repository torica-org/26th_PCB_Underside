# Repository torica-org/26th_PCB_Underside

File README.md:

# 26th_PCB_Underside
機体下電装部のPCB

## KiCad design fm/Underside.kicad_pcb

Parts:
J1: Micro_SD_Card_Det_Hirose_DM3AT; microSD_AE-MICRO-SD-DIP
J2: Conn_01x03_Socket; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J3: Conn_01x04_Socket; PinSocket_1x04_P2.54mm_Vertical
U2: URM-37; URM37
U3: SeeeduinoXIAO; XIAO-RP2040-DIP
Under_URAT1: TORICA_URAT1; PA_Connector_Post_4Pin

Connections:
+3.3V: J1.4 (VDD), J2.3, J3.1, U2.1 (VCC), U3.12 (3V3)
+5V: U3.14 (5V), Under_URAT1.4
/CS: J1.2 (DAT3/CD), U3.3 (PA10_A2_D2)
/PRXT: U3.7 (PB08_A6_D6_TX), Under_URAT1.2
/PTXR: U3.8 (PB09_A7_D7_RX), Under_URAT1.3
/SCK: J3.3, U3.6 (PA9_A5_D5_SCL)
/SDI: J3.4, U3.5 (PA8_A4_D4_SDA)
GND: J1.6 (VSS), J2.1, J3.2, U2.2 (GND), U3.13 (GND), Under_URAT1.1
unnamed: J1.5 (CLK), U3.9 (PA7_A8_D8_SCK)
unnamed: J1.3 (CMD), U3.11 (PA6_A10_D10_MOSI)
unnamed: J1.7 (DAT0), U3.10 (PA5_A9_D9_MISO)
unnamed: J2.2, U3.4 (PA11_A3_D3)
unnamed: U2.6 (COMP/TRIG), U3.2 (PA4_A1_D1)
unnamed: U2.4 (ECHO), U3.1 (PA02_A0_D0)

Notes on the sheet:
LiDARへ
mainから

Board: 2 copper layers, 90.0 x 59.0 mm, 6 parts (0 on the bottom side), 14 nets.

File fm/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"_2, ",,2,,
J1,microSD_AE-MICRO-SD-DIP,1,Micro_SD_Card_Det_Hirose_DM3AT,
J2,JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal,1,Conn_01x03_Socket,
J3,PinSocket_1x04_P2.54mm_Vertical,1,Conn_01x04_Socket,
U2,URM37,1,URM-37,
U3,XIAO-RP2040-DIP,1,SeeeduinoXIAO,
UNDER_URAT1,PA_Connector_Post_4Pin,1,TORICA_URAT1,

## KiCad design Underside_kicad_26th_new/Underside.kicad_pcb

Board: 2 copper layers, 47.5 x 72.0 mm, 5 parts (0 on the bottom side), 13 nets.

Parts:
DPS310: DPS310
J1: Micro_SD_Card_Det_Hirose_DM3AT; microSD_AE-MICRO-SD-DIP
U3: XIAO RP2040; Seeeduino XIAO-MOUDLE14P-2.54-21X17.8MM
URM37: URM-37; URM37
Under_URAT: TORICA_URAT1; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal

Connections:
+3.3V: DPS310.1 (VCC), J1.4 (VDD), U3.12 (3V3), URM37.1 (VCC)
+5V: U3.14 (5V), Under_URAT.2
/CS: J1.2 (DAT3/CD), U3.3 (PA10_A2_D2)
/PRXT: U3.7 (PB08_A6_D6_TX), Under_URAT.4
/PTXR: U3.8 (PB09_A7_D7_RX), Under_URAT.3
GND: DPS310.3 (GND), J1.6 (VSS), U3.13 (GND), URM37.2 (GND), Under_URAT.1
unnamed: J1.5 (CLK), U3.9 (PA7_A8_D8_SCK)
unnamed: J1.3 (CMD), U3.11 (PA6_A10_D10_MOSI)
unnamed: J1.7 (DAT0), U3.10 (PA5_A9_D9_MISO)
unnamed: DPS310.5 (CSK), U3.6 (PA9_A5_D5_SCL)
unnamed: DPS310.2 (SDI), U3.5 (PA8_A4_D4_SDA)
unnamed: U3.2 (PA4_A1_D1), URM37.6 (COMP/TRIG)
unnamed: U3.1 (PA02_A0_D0), URM37.4 (ECHO)

## Commit log

2026-05-13 addundersidepcb
2026-06-02 add fm
2026-06-21 new under
2026-06-21 reset
2026-06-21 re-production
